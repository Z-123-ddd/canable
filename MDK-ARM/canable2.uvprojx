# Keil uVision project canable2.uvprojx, settings and files
target canable2 (6180000::V6.18::ARMCLANG)
  device: N32H473CE Nationstech
  pack: Nationstech.N32H47x_DFP.0.8.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: canable2 +hex
  AfterMake: fromelf --bin --output=.\Objects\canable2.bin .\Objects\canable2.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8
  c define: N32H473,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,HSE_VALUE=24000000,INTERNAL_OSCILLATOR
  c misc: -include git_version.h -Wall
  c include: ..\Drivers\CMSIS;..\Drivers\N32H47x_48x_HAL_Driver\Inc;..\Drivers\USB_Device_Library\Inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group USER
    ../src/: main.c system.c system_n32h47x_48x.c can.c can_timer.c can_frame_list.c dfu.c usb_proto.c slcan.c led.c error.c printf.c interrupts.c usbd_cdc_if.c usb_istr.c usb_desc.c usb_prop.c usb_pwr.c usb_endp.c
  group STARTUP
    ./: startup_n32h473.s
  group HAL_Driver
    ../Drivers/N32H47x_48x_HAL_Driver/Src/: misc.c n32h47x_48x_adc.c n32h47x_48x_comp.c n32h47x_48x_cordic.c n32h47x_48x_crc.c n32h47x_48x_dac.c n32h47x_48x_dbg.c n32h47x_48x_dma.c n32h47x_48x_dvp.c n32h47x_48x_eth.c n32h47x_48x_exti.c n32h47x_48x_fdcan.c n32h47x_48x_femc.c n32h47x_48x_flash.c n32h47x_48x_fmac.c n32h47x_48x_gpio.c n32h47x_48x_i2c.c n32h47x_48x_iwdg.c n32h47x_48x_lptim.c n32h47x_48x_pga.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_rtc.c n32h47x_48x_sdio.c n32h47x_48x_shrtim.c n32h47x_48x_spi.c n32h47x_48x_tim.c n32h47x_48x_usart.c n32h47x_48x_vrefbuf.c n32h47x_48x_wwdg.c n32h47x_48x_xspi.c
  group USB_Device_Library
    ../Drivers/USB_Device_Library/Src/: usbfsd_core.c usbfsd_init.c usbfsd_int.c usbfsd_mem.c usbfsd_regs.c usbfsd_sil.c
